## boards/arm/moon68/Kconfig.board
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config BOARD_MOON68
	bool "moon68"
	depends on SOC_NRF52840_QIAA
```
